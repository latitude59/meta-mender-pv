require recipes-bsp/u-boot/u-boot-mender.inc
RPROVIDES_${PN} += "u-boot"
